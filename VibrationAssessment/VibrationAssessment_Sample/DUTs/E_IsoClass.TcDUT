(* ISO Classes *)
{attribute 'qualified_only'}
TYPE E_IsoClass :
(
	Error := -2,
	A,
	B,
	C,
	D
) DINT;
END_TYPE
